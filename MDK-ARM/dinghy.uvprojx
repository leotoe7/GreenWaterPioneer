# Keil uVision project dinghy.uvprojx, settings and files
target dinghy (6190000::V6.19::ARMCLANG)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: dinghy +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../RT-Thread;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;./mylibs;./mylibs/cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ./: app_rt_thread.c
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group mylibs
    ./mylibs/: ds18b20.c ds18b20.h NMEA0183.c NMEA0183.h osdelay.h osdelay.c
  group cJSON
    ./mylibs/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h cJSON_test.c cJSON_test.h
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
software components: CMSIS:CORE 5.6.0
